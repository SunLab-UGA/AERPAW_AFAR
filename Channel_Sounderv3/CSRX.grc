options:
  parameters:
    generate_options: qt_gui
    id: CSRX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.99'
  states: {}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '90'
    value: '30'
  states: {}
- name: lbc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.0001'
    step: '0.0001'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-gainrx'
    type: float
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/Power
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /root/Quality
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '3'
    n: '4095'
    offset: '1'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1000'
    n: '4095'
    offset: '2000'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: '3'
    offset: '2'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_1_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: '1000'
    offset: '999'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: sps
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '3'
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: complex
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4095'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4095'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: lbc
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='My Block',   # will show up in GRC
                  in_sig=[(np.complex64,4095)],
                  out_sig=[(np.complex64,4095)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
      #        output_items[0][:] = input_items[0] * self.example_param
              #print(output_items[0][0][indx])        
              #print(abs(output_items[0][0][indx]))        
              for i in range(0,len(input_items[0])):
                  indx=abs(input_items[0][i]).argmax()
                  #print(max(output_items[0][i]))
                  input_items[0][i]=np.roll(input_items[0][i],-1*indx+2)
                  output_items[0][i][:] = input_items[0][i] * self.example_param
              return len(output_items[0])
    example_param: '1'
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: '1'
    nthreads: '8'
    samp_rate: samp_rate/sps
    taps: (-1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,    -1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,     1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,     1,     1,    -1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,     1,    -1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,    -1,     1,    -1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,    -1,    -1,    -1,     1,    -1,    -1,     1,     1,    -1,     1,     1,     1,     1,     1,    -1,     1,     1,     1,    -1,     1,    -1,    -1,     1,    -1,     1,     1,     1,     1,     1,     1,     1,    -1,    -1,     1,     1,     1,    -1,     1,     1,     1,     1)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    marker2: '1'
    marker3: '3'
    nconnections: '3'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '80'
    ymin: '-40'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    marker2: '1'
    size: '4095'
    srate: samp_rate/sps
    type: complex
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    marker2: '1'
    size: '4095'
    srate: samp_rate/sps
    type: complex
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: 4095*sps
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '0'
    marker2: '0'
    size: '4095'
    srate: samp_rate/sps
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 10*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: 3.5e9
    dc_offs_enb0: '""'
    gain0: gainrx
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: stream1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: stream2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: stream1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: stream2
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_keep_m_in_n_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_keep_m_in_n_1_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_keep_m_in_n_1, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_keep_m_in_n_1_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_sub_xx_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_1_0, '2']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_1_0_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0_0_0_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_time_sink_x_1_0_0_0_1, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_0, '0', virtual_sink_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [uhd_usrp_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [virtual_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [virtual_source_0_0, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
